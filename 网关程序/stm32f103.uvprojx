# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\EDP;.\NET\device\inc;.\hardware\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_md.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_fsmc.c
  group hardware
    ./hardware/src/: delay.c usart.c hwtimer.c info.c selfcheck.c clock.c rtc.c gpio.c sys.c
    ./hardware/LCD/: lcd.c
  group user
    ./user/: main.c dataStreamName.h
  group OneNET
    ./NET/onenet/src/: onenet.c fault.c
  group net_protocol
    ./NET/EDP/: EdpKit.c dStream.c
  group net_device
    ./NET/device/src/: net_io.c net_device.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
